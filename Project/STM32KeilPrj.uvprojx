# Keil uVision project STM32KeilPrj.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32KeilPrj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\App\Main;..\App\DataType;..\HW\RCC;..\HW\Timer;..\HW\UART1;..\FW\inc;..\ARM\NVIC;..\ARM\SysTick;..\ARM\System;..\App\LED;..\App\KeyOne;..\HW\PWM;..\App\Motor;..\App\Heat;..\App\Audio;..\OS\portable;..\OS\include;..\OS\portable\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/Main/: Main.c FreeRTOSConfig.h
    ../App/LED/: LED.c
    ../App/KeyOne/: KeyOne.c ProcKeyOne.c
    ../App/Audio/: Audio.c
    ../App/Heat/: Heat.c
    ../App/Motor/: Motor.c
  group HW
    ../HW/RCC/: RCC.c
    ../HW/Timer/: Timer.c
    ../HW/UART1/: UART1.c UARTQueue.c
    ../HW/PWM/: PWM.c
  group OS
    ../OS/Source/: timers.c tasks.c stream_buffer.c queue.c list.c event_groups.c croutine.c
    ../OS/portable/: heap_4.c
    ../OS/portable/ARM_CM3/: port.c
  group FW
    ../FW/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group ARM
    ../ARM/NVIC/: NVIC.c
    ../ARM/SysTick/: SysTick.c
    ../ARM/System/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
